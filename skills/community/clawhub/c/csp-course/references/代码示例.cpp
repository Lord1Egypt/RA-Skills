// ============================================================
// 信息学 C++ · 函数专题 · 素数计数
// 课件配套代码示例
// ============================================================

// ────────────────────────────────────────────────────────────
// 【第1关】函数基本语法示意
// ────────────────────────────────────────────────────────────

bool isPrime(int n) {   // 接受一个整数 n
    // ...处理逻辑...
    return true;        // 告诉你结果（true 或 false）
}


// ────────────────────────────────────────────────────────────
// 【第2关】isPrime() 完整实现（侦探版）
//   ① n≤1 直接返回 false
//   ② 从 2 试到 √n（i*i <= n），省力！
//   ③ 能被整除 → 立刻返回 false
//   ④ 全部通过 → 返回 true
// ────────────────────────────────────────────────────────────

bool isPrime(int n) {
    // ① 不是素数：n<=1
    if (n <= 1)
        return false;
    // ②③ 从2试到√n
    for (int i = 2; i * i <= n; i++) {
        // ④ 能整除？不是素数
        if (n % i == 0)
            return false;
    }
    // ⑤ 全部通过！
    return true;
}


// ────────────────────────────────────────────────────────────
// 【第3关】完整程序：读入 N，统计 2~N 内素数个数
// ────────────────────────────────────────────────────────────

#include <iostream>
using namespace std;

bool isPrime(int n) {
    if (n <= 1) return false;
    for (int i = 2; i * i <= n; i++)
        if (n % i == 0) return false;
    return true;
}

int main() {
    int N, count = 0;
    cin >> N;
    for (int i = 2; i <= N; i++)
        if (isPrime(i))
            count++;
    cout << count;
    return 0;
}


// ────────────────────────────────────────────────────────────
// 【第5关】慢方法 vs 聪明方法对比
// ────────────────────────────────────────────────────────────

// 🐌 慢方法（不推荐）：i 从 2 遍历到 n-1，最多试 n-2 次
bool isPrime_slow(int n) {
    for (int i = 2; i < n; i++)
        if (n % i == 0) return false;
    return true;
}

// 🚀 聪明方法（推荐）：i 只试到 √n，最多试 √n 次
bool isPrime_fast(int n) {
    if (n <= 1) return false;
    for (int i = 2; i * i <= n; i++)
        if (n % i == 0) return false;
    return true;
}

// 对比示例（n = 100）：
//   慢方法：试 2,3,4,...,99  共 98 次
//   聪明方法：√100=10，试 2,3,...,10  共 9 次


// ────────────────────────────────────────────────────────────
// 【挑战关】三个 Bug 分析
// ────────────────────────────────────────────────────────────

// ❌ Bug 1：缺少 n<=1 的判断，1 会被误判为素数
bool isPrime_bug1(int n) {
    for (int i = 2; i * i <= n; i++)
        if (n % i == 0) return false;
    return true; // n=1 时循环不执行，直接返回 true（错！）
}
// ✅ 修正：在开头加上 if(n<=1) return false;

// ❌ Bug 2：主函数从 i=1 开始，会把 1 也计入素数
void count_bug2(int N) {
    int count = 0;
    for (int i = 1; i <= N; i++)   // 应从 i=2 开始
        if (isPrime(i)) count++;
}
// ✅ 修正：改为 for(int i=2; i<=N; i++)

// ❌ Bug 3：循环条件 i<n，效率低（未做 √n 优化）
bool isPrime_bug3(int n) {
    for (int i = 2; i < n; i++)    // 应改为 i*i <= n
        if (n % i == 0) return false;
    return true;
}
// ✅ 修正：改为 i*i<=n，只需试到 √n，效率大幅提升
